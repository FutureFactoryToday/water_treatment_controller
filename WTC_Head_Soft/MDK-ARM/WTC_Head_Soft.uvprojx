# Keil uVision project WTC_Head_Soft.uvprojx, settings and files
target WTC_Head_Soft (6190000::V6.19::ARMCLANG)
  device: STM32F103RG STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80FFFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: WTC_Head_Soft +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=1
  c define: STM32F103xG,USE_HAL_DRIVER,USE_FULL_LL_DRIVER, NO_FLOAT
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../UserLibs/GUI;../UserLibs/HardSettings;../UserLibs/LowLevel;../UserLibs/SystemLibs
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application/MDK-ARM
    ./: startup_stm32f103xg.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c crc.c dma.c i2c.c rtc.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_ll_rcc.c stm32f1xx_ll_utils.c stm32f1xx_ll_exti.c stm32f1xx_hal_crc.c stm32f1xx_hal_i2c.c stm32f1xx_ll_rtc.c stm32f1xx_ll_gpio.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group WTC_Hard_Config
    ../UserLibs/HardSettings/: uC_Settings.h System_Settings.h
  group System Libs
    ../UserLibs/LowLevel/Time/: Time.c
    ../UserLibs/SystemLibs/System/: System.c
    ../UserLibs/SystemLibs/Planner/: Planner.c
    ../UserLibs/SystemLibs/PistonControl/: PistonControl.c
    ../UserLibs/SystemLibs/Logic/: WTC_Logic.c
    ../UserLibs/SystemLibs/Filter/: filter.c
    ../UserLibs/SystemLibs/Util/: Util.c
  group GUI
    ../UserLibs/LowLevel/TFT/Fonts/: oxy_24.c oxy_20.c oxy_16.c oxy_12.c oxy_8.c
    ../UserLibs/GUI/: GUI.c
    ../UserLibs/GUI/PicArrays/: arrayPicDay.c arrayPicList.c arrayPicNight.c arrowDownImg.c arrowUpImg.c checkMarkImg.c dropButImg.c dropButImgRect.c homeButImg.c leftArrowImg.c MAIN_LOGO.c pageButImg.c mocSmallImg.c pageButImgRect.c returnArrowImg.c rightArrowImg.c smalLogo.c TestBMP.c trashImg.c wrenchButImg.c wrenchButImgRect.c wrenchButPhantom.c
    ../UserLibs/GUI/Frames/: adjustmentFrame.c alarmListFrame.c alarmNotiFrame.c Calendar.c clockSet.c dateSet.c daysBetweenRegenCustomerFrame.c delayedRegenCustomerFrame.c elMagFrame.c filterCycleFrame.c filteringFrame.c filterSelectionFrame.c forcedRegenCustomerFrame.c historyErrorsFrame.c historyFilterFrame.c historyMaxWaterFrame.c historyMenuFrame.c historyWaterFrame.c inputOneFrame.c items.c keyboardFrame.c layout.c loadTypeFrame.c mainFrame.c mainMenuFrame.c ManualDriveControl.c ManualFilteringSettings.c menuFrame.c periodRegenFrame.c PinCode.c quantityCountServiceFrame.c regenPeriodServiceFrame.c regenServiceFrame.c serviceDateSelect.c ServiceInfo.c serviceMenuFrame.c softeningFrame.c stepsFrame.c timeSetFrame.c universalOutputFrame.c washingTimeCustomerFrame.c washingTimeServiceFrame.c waterCountBeforeRegen.c widgets.c
  group Low level libs
    ../UserLibs/LowLevel/FlashParams/: FlashParam.c
    ../UserLibs/LowLevel/FlowMeter/: FlowMeter.c
    ../UserLibs/LowLevel/Motor/: Motor.c
    ../UserLibs/LowLevel/Optic/: Optic.c
    ../UserLibs/LowLevel/Service/: Service.c
    ../UserLibs/LowLevel/SPI/: SPI_Handler.c FIFO.c
    ../UserLibs/LowLevel/TFT/: stm32_adafruit_lcd.c stm32_adafruit_ts.c
    ../UserLibs/LowLevel/TFT/stm32f1xx/: ts_xpt2046.c lcd_io_spi.c
    ../UserLibs/LowLevel/TFT/lcd/st7796s/: st7796s.c
    ../UserLibs/LowLevel/TouchController/: TouchController.c
    ../UserLibs/LowLevel/UART/: UART_COM.c
    ../UserLibs/LowLevel/FlashIC/: FM25.c
software components: CMSIS:CORE 5.6.0
