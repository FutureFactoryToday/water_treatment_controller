# Keil uVision project SPO_ProdTest.uvprojx, settings and files
target SPO (6190000::V6.19::ARMCLANG)
  device: STM32F103RG STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80FFFFF) CLOCK(16000000) CPUTYPE("Cortex-M3") TZ
  output: SPO +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=6 wLevel=1
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=16000000,STM32F103xG, _24bit_FORMAT,USE_HAL_DRIVER, NOT_CLEAR_LOG, OPTIC_TEST
  c include: ../Core_ProdTest/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../UserCore;../MidLevel;../Drivers;../../info/datasheets/4.0inch_SPI_Module_ILI9486_MSP4022&MSP4023_V1.0/1-Demo/Demo_STM32/Demo_STM32F103RCT6_Hardware_SPI;../../GUI/Logo;../UpperLevel;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application/MDK-ARM
    ./: startup_stm32f103xg.s
  group Application/User/Core
    ../Core_ProdTest/Src/: main_ProdTest.c gpio.c adc.c crc.c dma.c i2c.c iwdg.c rtc.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_ll_gpio.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_ll_rcc.c stm32f1xx_ll_utils.c stm32f1xx_ll_exti.c stm32f1xx_hal_crc.c stm32f1xx_ll_dma.c stm32f1xx_hal_i2c.c stm32f1xx_hal_iwdg.c stm32f1xx_ll_rtc.c stm32f1xx_hal_spi.c stm32f1xx_ll_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_ll_tim.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core_ProdTest/Src/: system_stm32f1xx.c
  group Settings
    ../UpperLevel/HardSettings/: uC_Settings.h System_Settings.h
  group Libs
    ../UserCore/SPI/: FIFO.c
    ../UserCore/Logic/: WTC_Logic.c
    ../UpperLevel/Motor/: Motor.c
    ../UpperLevel/PistonControl/: PistonControl.c
    ../UpperLevel/Time/: Time.c Alarm.c
    ../UpperLevel/FlashParams/: FlashParam.c
    ../UpperLevel/Util/: Util.c
    ../UpperLevel/System/: System.c
    ../UpperLevel/FlowMeter/: FlowMeter.c
    ../UpperLevel/Planner/: Planner.c
    ../UpperLevel/Filter/: filter.c
    ../UpperLevel/FlashIC/: FM25.c W25.c
    ../UpperLevel/Relays/: Relay.c
    ../UpperLevel/Logger/: Logger.c
  group Info
    ../../../IronSolder/SolderSPO/libs/I2C/: I2C_Handler.c I2C_LL.c
    ../../../IronSolder/SolderSPO/libs/Filter/: filter.c
    ../../../IronSolder/SolderSPO/libs/SSD1306/: ssd1306.c
    ../../../IronSolder/SolderSPO/libs/MCP3421/: MCP3421.c
    ../../../IronSolder/SolderSPO/libs/ADT7320/: ADT7320.c
    ../../../SolderSPO/Src/: dma.c stm32f0xx_it.c
  group DS
    ../../info/datasheets/: ILI9486_Datasheet.pdf
  group LCD
    ../UpperLevel/GUI/: TouchController.c
    ../UpperLevel/TFT/: stm32_adafruit_ts.c stm32_adafruit_lcd.c
    ../UpperLevel/TFT/stm32f1xx/: ts_xpt2046.c lcd_io_spi.c
    ../UpperLevel/TFT/lcd/st7796s/: st7796s.c
    ../UpperLevel/TFT/lcd/FT6336/: ctpiic.c ft6336.c
software components: CMSIS:CORE 5.6.0
