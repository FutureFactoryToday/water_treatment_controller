# Keil uVision project SPO.uvprojx, settings and files
target SPO (6160000::V6.16::ARMCLANG)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: SPO +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 wLevel=1
  c define: USE_FULL_LL_DRIVER,STM32F103xE,USE_FULL_ASSERT=1U,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,HSI_VALUE=8000000,LSI_VALUE=40000,VDD_VALUE=3300,PREFETCH_ENABLE=1
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Core;../MidLevel;../Drivers;../../info/datasheets/4.0inch_SPI_Module_ILI9486_MSP4022&MSP4023_V1.0/1-Demo/Demo_STM32/Demo_STM32F103RCT6_Hardware_SPI;../../GUI/Logo;../UpperLevel
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c rtc.c spi.c tim.c usart.c stm32f1xx_it.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_ll_gpio.c stm32f1xx_ll_rtc.c stm32f1xx_ll_rcc.c stm32f1xx_ll_utils.c stm32f1xx_ll_exti.c stm32f1xx_ll_spi.c stm32f1xx_ll_dma.c stm32f1xx_ll_pwr.c stm32f1xx_ll_tim.c stm32f1xx_ll_usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Settings
    ../Core/: Settings.h
  group Libs
    ../MidLevel/SPI/: FIFO.c
    ../Core/Src/: WTC_Logic.c
    ../Drivers/Motor/: Motor.c
    ../Drivers/Optic/: Optic.c
  group Info
    ../../../IronSolder/SolderSPO/libs/I2C/: I2C_Handler.c I2C_LL.c
    ../../../IronSolder/SolderSPO/libs/Filter/: filter.c
    ../../../IronSolder/SolderSPO/libs/SSD1306/: ssd1306.c
    ../../../IronSolder/SolderSPO/libs/MCP3421/: MCP3421.c
    ../../../IronSolder/SolderSPO/libs/ADT7320/: ADT7320.c
    ../../../SolderSPO/Src/: dma.c stm32f0xx_it.c
  group DS
    ../../info/datasheets/: ILI9486_Datasheet.pdf
  group GUI
    ../../GUI/Logo/: LOGO_MAIN2.c smallLogo_16b.c
    ../Drivers/TFT/Fonts/: font8.c font12.c font16.c font20.c font24.c Oxygen_Mono.c
    ../UpperLevel/GUI/: GUI.c
  group LCD
    ../Drivers/TFT/: stm32_adafruit_lcd.c stm32_adafruit_ts.c
    ../Drivers/TFT/lcd/ili9486/: ili9486.c
    ../Drivers/TFT/stm32f1xx/: ts_xpt2046.c lcd_io_spi.c
target TESTS (6180000::V6.18::ARMCLANG)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: as above
  output: SPO +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_FULL_LL_DRIVER,USE_FULL_ASSERT=1U,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,HSI_VALUE=8000000,LSI_VALUE=40000,VDD_VALUE=3300,PREFETCH_ENABLE=1,STM32F103xE, TESTS
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Core;../MidLevel;../Drivers
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target Sim (6180000::V6.18::ARMCLANG)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: as above
  output: SPO +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_FULL_LL_DRIVER,USE_FULL_ASSERT=1U,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,HSI_VALUE=8000000,LSI_VALUE=40000,VDD_VALUE=3300,PREFETCH_ENABLE=1,STM32F103xE, TESTS, SIM
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
